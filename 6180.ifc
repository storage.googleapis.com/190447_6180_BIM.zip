Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-09-11T16:06:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 11 16:06:23 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{EA037459-1A1E-4124-A9C4-D7A424F992BB}\ifc * Database version: 5507 * Database creation date: Tue Sep 11 16:06:22 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 11 16:06:23 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 11 16:06:23 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6180 Shower faucet, 6 V, 6180:6180 Shower faucet, 6 V:347841
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 106.6 mm; NominalHeight: 84 mm; NominalWidth: 222 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6180; ConvergoRefNr: 0087-1809-0059-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_07; Uniclass2015Description: Bath manual water supply sets; Uniclass2015Reference: Pr_40_20_87_07; Version: 1; VersionDate: 30/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150052491; EMC Directive: 89/336/EEC; LVI Number: 6319550; Noise Class: II (ISO 3822) Oras lab.; NRF Number: 4200482; Protection Class: IP 55; RSK Number: 8126185
Type - Identity Data(Type) - Class: Battery-operated, touchless; Group: Shower faucets; Manufacturer: Oras; Market: INT;EST;FIN;LVA;LTU;POL;SWE;UKR;RUS; Model: 6180 Shower faucet, 6 V; Name_en: 6180 Shower faucet, 6 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6180; Product Datasheet: https://www.oras.com/datasheet/6180/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6180; Type Name: 6180 Shower faucet, 6 V; Usage Group: Shower facilities (public saunas, swimming baths)
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Afterflow Period: 5; Connection Size: G3/4; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/110208_PDM_945443_7_(945443-06-14).pdf; Installation Type: Wall-mounted; Installation Width: CC 150± 3 mm; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 300; Mechanical Parts: Litter filter(s), non-return valve(s); Opening Range: 0 - 5 cm; Pressure Loss With Flow 02ls: 300000 Pa; Recognition Range: 60 cm (50 / 60 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6180/; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower, public & semi-public, health & care; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6180; Features: Battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6180; Name: 6180 Shower faucet, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: 220x105x85 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6180; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6180 Shower faucet, 6 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0532703 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00200025 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6180: 6180 Shower faucet, 6 V; Family and Type: 6180: 6180 Shower faucet, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6180: 6180 Shower faucet, 6 V; Type Id: 6180: 6180 Shower faucet, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
